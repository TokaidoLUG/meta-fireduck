DESCRIPTION = "Fireduck OS image enlightenment append" 

IMAGE_INSTALL_append = " \
    packagegroup-enlightenment \
    "

