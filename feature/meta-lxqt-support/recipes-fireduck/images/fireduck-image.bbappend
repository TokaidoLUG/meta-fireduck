DESCRIPTION = "Fireduck OS image lxqt append" 


IMAGE_INSTALL_append = " \
    packagegroup-lxqt-base \
"
