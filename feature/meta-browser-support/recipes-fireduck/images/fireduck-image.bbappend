DESCRIPTION = "Fireduck OS image browser append" 

IMAGE_INSTALL_append = " \
    packagegroup-mozilla \
    "

