DESCRIPTION = "Fireduck OS image kde append" 


IMAGE_INSTALL_append = " \
    plasma-world \
"
